# Keil uVision project XB-Techeart.uvproj, settings and files
target Target 1 (MCS-51)
  device: N79E814 Nuvoton
  cpu: IRAM(0x00-0xFF) IROM(0x000-0x1FFF) XRAM(0x00-0xFF) CLOCK(24000000)
  output: XB-Techeart +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 XB-Z.c hSch51.c Timer.c UART.c Button.c ISP_DataFlash.c Selflearn.c Speech.c Delay.c IIC.c KBI.c Alarm.c Battery.c Clock.c
